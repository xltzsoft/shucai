# IAR project I2C_TwoBoardsPolling.ewp, settings and files
configuration APM32F402 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F402xB Geehy APM32F402xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_DAL_DRIVER; APM32F402xx; BOARD_APM32F402_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\APM32F4xx_DAL_Driver\Include; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\Config\Include; ..\..\..\..\..\..\Boards\Board_APM32F402_Tiny\Include; ..\..\..\..\..\..\Boards\Components\LOG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_TwoBoardsPolling.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APM32F4xx_DAL_Driver
    ../../../../../../Libraries/APM32F4xx_DAL_Driver/Source/: apm32f4xx_dal.c apm32f4xx_dal_cortex.c apm32f4xx_dal_dma.c apm32f4xx_dal_dma_ex.c apm32f4xx_dal_eint.c apm32f4xx_dal_flash.c apm32f4xx_dal_flash_ex.c apm32f4xx_dal_gpio.c apm32f4xx_dal_i2c.c apm32f4xx_dal_i2c_ex.c apm32f4xx_dal_pmu.c apm32f4xx_dal_pmu_ex.c apm32f4xx_dal_rcm.c apm32f4xx_dal_rcm_ex.c apm32f4xx_dal_uart.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c
    ../../../../../../Boards/Components/LOG/: log.c
  group Board
    ../../../../../../Boards/Board_APM32F402_Tiny/Source/: board_apm32f402_tiny.c
  group CMSIS
    ./: startup_apm32f402xx.s
    ../../Source/: system_apm32f4xx.c
  group Config
    ../../Config/Include/: apm32f4xx_dal_cfg.h
    ../../Config/Source/: apm32f4xx_device_cfg.c apm32f4xx_gpio_cfg.c apm32f4xx_i2c_cfg.c apm32f4xx_nvic_cfg.c apm32f4xx_rcm_cfg.c apm32f4xx_usart_cfg.c
  group Document
    ../../: readme.txt
