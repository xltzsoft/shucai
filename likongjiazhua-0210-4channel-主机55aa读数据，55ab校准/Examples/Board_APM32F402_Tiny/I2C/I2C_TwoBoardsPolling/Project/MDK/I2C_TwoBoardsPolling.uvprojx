# Keil uVision project I2C_TwoBoardsPolling.uvprojx, settings and files
target APM32F402 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_TwoBoardsPolling +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER, APM32F402xx, BOARD_APM32F402_TINY
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\APM32F4xx_DAL_Driver\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Boards\Board_APM32F402_Tiny\Include;..\..\Config\Include;..\..\..\..\..\..\Boards\Components\LOG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f402xx.s
  group APM32F4xx_DAL_Driver
    ../../../../../../Libraries/APM32F4xx_DAL_Driver/Source/: apm32f4xx_dal.c apm32f4xx_dal_cortex.c apm32f4xx_dal_dma.c apm32f4xx_dal_dma_ex.c apm32f4xx_dal_eint.c apm32f4xx_dal_flash.c apm32f4xx_dal_flash_ex.c apm32f4xx_dal_gpio.c apm32f4xx_dal_pmu.c apm32f4xx_dal_pmu_ex.c apm32f4xx_dal_rcm.c apm32f4xx_dal_rcm_ex.c apm32f4xx_dal_uart.c apm32f4xx_dal_i2c.c apm32f4xx_dal_i2c_ex.c apm32f4xx_dal_spi.c apm32f4xx_dal_usart.c
  group Board
    ../../../../../../Boards/Board_APM32F402_Tiny/Source/: board_apm32f402_tiny.c
  group Config
    ../../Config/Include/: apm32f4xx_dal_cfg.h
    ../../Config/Source/: apm32f4xx_device_cfg.c apm32f4xx_rcm_cfg.c apm32f4xx_gpio_cfg.c apm32f4xx_nvic_cfg.c apm32f4xx_usart_cfg.c apm32f4xx_spi_cfg.c apm32f4xx_i2c_cfg.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c flash_read_write.c
    ../../../../../../Boards/Components/LOG/: log.c
  group Document
    ../../: readme.txt
